Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: KOP_M_2,5m.IFC
Time: 2023-05-08T10:21:13
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m
