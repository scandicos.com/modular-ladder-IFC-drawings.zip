Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: KOP_M_8m.IFC
Time: 2023-05-08T10:03:33
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude1 (16)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude1[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude1[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[1] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[2] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[3] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[4] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4[1] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4[2] (8)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude6[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude6[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude7 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet1 (18)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet2 (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: KOP_14_Default<As Machined> (2)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_3 (14)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_6_Default<As Machined> (8)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_7_Default<As Machined> (25)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_8_Default<As Machined> (10)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_B_01_8000
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(2) (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[4] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Trim/Extend1[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Vamzdis din 2448 42,4X2(1) (16)
In: Default Storey
PredefinedType: ELEMENT
