Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: KOP_14.5.IFC
Time: 2023-10-20T08:48:22
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: Boss-Extrude1 (33)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude1[1] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude1[2] (2)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[10]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[11]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[12]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[8]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude2[9]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[1] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[2] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[3] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude3[4] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4[1] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude4[2] (31)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude5[1] (7)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude5[2] (7)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude6[1] (11)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude6[2] (11)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Cut-Extrude7 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet1 (36)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet2 (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Fillet4
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: KOP_14_Default<As Machined> (28)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_20
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_21
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_3 (28)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_6_Default<As Machined> (33)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_7_Default<As Machined> (70)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_8_Default<As Machined> (20)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: KOP_B_01_13500
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(2) (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[1] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[2] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Lygiasonis kampuotis din 1028 50X50X4(3)[4] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[3]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[4]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[5]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[6]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Mirror3[7]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Poverzle DIN 125A_Poverzle DIN 125A - 8 (48)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Poverzle DIN 127 (24)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Sraigtas ISO 7380_Sraigtas ISO 7380 - M8 x 25 (25)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: Trim/Extend1[2] (4)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Trim/Extend2[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Trim/Extend3[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Trim/Extend4[1]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Trim/Extend4[2]
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Vamzdis din 2448 42,4X2(1) (32)
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Verzle DIN 934_Verzle DIN 934 - M8 (25)
In: Default Storey
PredefinedType: ELEMENT; Material: 0
